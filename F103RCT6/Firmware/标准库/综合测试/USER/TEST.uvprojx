# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\FLASH;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\NRF24L01;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\HARDWARE\PS2;..\HARDWARE\STMFLASH;..\HARDWARE\SD;..\HARDWARE\TPAD;..\HARDWARE\MPU6050;..\MALLOC;..\FATFS\src;..\FATFS\exfuns;..\TEXT;..\PICTURE;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOSII\CONFIG;..\USB\LIB;..\USB\CONFIG;..\T9INPUT;..\ATKNCR;..\GUI;..\APP;..\STM32F10x_FWLib\inc;..\USER;..\CORE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/TOUCH/: touch.c ctiic.c gt9147.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group UCOSII_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group GUI
    ../GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c
  group T9INPUT
    ../T9INPUT/: pyinput.c t9input.c
  group ATKNCR
    ../ATKNCR/: atk_ncr.c ATKNCR_M_V2.0.lib
  group APP
    ../APP/: common.c mainui.c ebook.c picviewer.c usbplay.c appplay.c calendar.c settings.c paint.c wirelessplay.c notepad.c
  group USB-LIB
    ../USB/LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB-CFG
    ../USB/CONFIG/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
